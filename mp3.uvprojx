# Keil uVision project mp3.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mp3
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL
  c include: .\Utilities\STM32_EVAL;.\Utilities\STM32_EVAL\Common;.\Utilities\STM32_EVAL\STM3210E_EVAL;.\SRC;.\SRC\File system;.\SRC\Decodeing System;.\SRC\Decodeing System\inc;.\SRC\Display;.\SRC\Periph settings;.\SRC\User Interface
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ./SRC/Main/: main.c
  group Decoding System
    ./SRC/Decodeing System/: decode.c bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3_play.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ./SRC/Decodeing System/arm/: asmmisc.S asmpoly_thumb2.S
  group Flie System
    ./SRC/File system/: diskio.c ff.c
  group Periph Settings
    ./SRC/Periph settings/: gpio_init.c sdio_init.c tim_init.c
  group Eval
    ./Utilities/STM32_EVAL/Common/: stm32_eval_sdio_sd.c
    ./Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0, CMSIS Driver:MCI 2.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
